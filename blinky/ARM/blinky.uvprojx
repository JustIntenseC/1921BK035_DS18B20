# Keil uVision project blinky.uvprojx, settings and files
target blinky (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: K1921VK035 Generic
  pack: NIIET.K1921VK035_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RETARGET, RETARGET_USE_UART, SYSCLK_PLL, CKO_NONE, OSECLK_VAL=16000000
  c include: ..\..\..\..\platform\CMSIS\Core\Include;..\..\..\..\platform\Device\NIIET\K1921VK035\Include;..\..\..\..\hardware\bsp\NIIET-BB-K1921VK035;..\..\..\..\platform\retarget;..\..\..\..\platform\retarget\Template\K1921VK035
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../../../../platform/Device/NIIET/K1921VK035/Source/: system_K1921VK035.c
    ../../../../platform/Device/NIIET/K1921VK035/Source/ARM/: startup_K1921VK035.s
  group src
    ../app/: main.c
  group bsp
    ../../../../hardware/bsp/NIIET-BB-K1921VK035/: bsp.c bsp.h
  group Retarget
    ../../../../platform/retarget/: retarget.c
    ../../../../platform/retarget/Template/K1921VK035/: retarget_conf.c retarget_conf.h
