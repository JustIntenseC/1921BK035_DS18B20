# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K1921VK035 NIIET K1921VK035
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: K1921VK035; OSECLK_VAL=16000000; SYSCLK_PLL; CKO_NONE; RETARGET; RETARGET_USE_UART
  ICCARM.CCIncludePath2: ../app; ../../../../platform/Device/NIIET/K1921VK035/Include; ../../../../platform/CMSIS/Core/Include; ../../../../platform/retarget/Template/K1921VK035; ../../../../platform/retarget; ../../../../hardware/bsp/NIIET-BB-K1921VK035
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../hardware/bsp/NIIET-BB-K1921VK035/: bsp.c
    ../app/: main.c
    ../../../../platform/retarget/: retarget.c
    ../../../../platform/retarget/Template/K1921VK035/: retarget_conf.c
    ../../../../platform/Device/NIIET/K1921VK035/Source/IAR/: startup_K1921VK035.S
    ../../../../platform/Device/NIIET/K1921VK035/Source/: system_K1921VK035.c
